# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x0f0
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: ..\STM8L15x_StdPeriph_Driver\inc; ..\user; ..\driver; ..\Lora; ..\at_cmd
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  postbuild: "$TOOLKIT_DIR$\bin\ielftool.exe" --bin --verbose  "$TARGET_PATH$" "$TARGET_BPATH$.bin"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\user\lnkstm8l051f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group at
    ../at_cmd/: at_cmd.c at_fun.c at_port.c
  group driver
    ../driver/: ebox_core.c ebox_pwm.c ebox_spi.c eeprom.c gpio.c timer.c usart.c
    ../user/: low_power.c
  group Lora
    ../Lora/: sx1278-Hal.c sx1278.c
  group StdPeriph_Driver
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    ../user/: main.c misc.c stm8l15x_it.c

<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>at</name>
    <file>
      <name>$PROJ_DIR$\..\at_cmd\at_cmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\at_cmd\at_fun.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\at_cmd\at_port.c</name>
    </file>
  </group>
  <group>
    <name>driver</name>
    <file>
      <name>$PROJ_DIR$\..\driver\ebox_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\ebox_pwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\ebox_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\low_power.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\usart.c</name>
    </file>
  </group>
  <group>
    <name>Lora</name>
    <file>
      <name>$PROJ_DIR$\..\Lora\sx1278-Hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Lora\sx1278.c</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_irtim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_wfe.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM8L15x_StdPeriph_Driver\src\stm8l15x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\user\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\stm8l15x_it.c</name>
    </file>
  </group>
</project>


